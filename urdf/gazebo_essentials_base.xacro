Commit message: Update gazebo_essentials_base.xacro

File: urdf/gazebo_essentials_base.xacro (robot description, xacro)
@@ -41,2 +41,5 @@
  <fdir1 value="1 0 0"/>
 </gazebo>
+</xacro:macro>
+<!--######################################################################-->
+</robot>
